# Keil uVision project Audio Module.uvprojx, settings and files
target AudioModule_Debug (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: GD32F150G8 GigaDevice
  pack: GigaDevice.GD32F1x0_DFP.3.1.0
  cpu: IRAM(0x20000000,0x02000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Audio Module +hex
  c flags: Optim=4 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\apps\inc;..\bsp\inc;..\hardware\GD32F1X0\CMSIS\Core;..\hardware\GD32F1X0\CMSIS\Include;..\hardware\GD32F1X0\Library\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Apps
    ../apps/src/: main.c SG.c
  group Bsp
    ../bsp/src/: Driver.c
  group Hardware/Config
    ../hardware/GD32F1X0/CMSIS/Include/: gd32f1x0_libopt.h
  group Hardware/CMSIS
    ../hardware/GD32F1X0/CMSIS/Source/: gd32f1x0_it.c system_gd32f1x0.c
  group Hardware/Driver
    ../hardware/GD32F1X0/Library/Source/: gd32f1x0_dac.c gd32f1x0_dbg.c gd32f1x0_dma.c gd32f1x0_fwdgt.c gd32f1x0_gpio.c gd32f1x0_rcu.c gd32f1x0_syscfg.c gd32f1x0_timer.c gd32f1x0_usart.c gd32f1x0_misc.c
  group Hardware/Startup
    ../hardware/GD32F1X0/Startup/ARM/GD32F150G8/: startup_gd32f1x0.s
  group Doc
    ../doc/: Readme.txt
target AudioModule_Release (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: GD32F150G8 GigaDevice
  pack: GigaDevice.GD32F1x0_DFP.3.1.0
  cpu: as above
  output: Audio Module +hex
  c flags: Optim=4 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: C:\Keil_v5\ARM\Pack\ARM\CMSIS\5.0.0-Beta4\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
